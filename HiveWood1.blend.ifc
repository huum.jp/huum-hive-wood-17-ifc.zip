Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: HiveWood1.blend.ifc
Time: 2023-04-13T18:15:55+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (369)
PredefinedType: ELECTRICACTUATOR
Name
1.052
1.053
49 x 1
54 x 2
52 x 3
53 x 4
50 x 5
54 x 6
50 x 7
Puuk__te_suur
My Storey.001
My Building.001
My Site.001
My Project.001
